inherit core-image

SUMMARY = "My custom image"
IMAGE_INSTALL = "packagegroup-core-boot ninvaders"

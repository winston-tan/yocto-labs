inherit core-image

SUMMARY = "My custom debug image"
IMAGE_INSTALL = "packagegroup-core-boot packagegroup-bootlinlabs-games dbg-pkgs"

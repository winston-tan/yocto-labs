SUMMARY = "My custom image"
IMAGE_INSTALL = "packagegroup-core-boot ${CORE_IMAGE_EXTRA_INSTALL} packagegroup-bootlinlabs-games"

inherit core-image
